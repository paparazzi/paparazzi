# IAR project ch.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F4xxx ST STM32F4xxx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORTEX_USE_FPU=FALSE
  ICCARM.CCIncludePath2: ..\; ..\..\..\os\kernel\include; ..\..\..\os\ports\common\ARMCMx; ..\..\..\os\ports\common\ARMCMx\CMSIS\include; ..\..\..\os\ports\IAR\ARMCMx; ..\..\..\os\ports\IAR\ARMCMx\STM32F4xx; ..\..\..\os\hal\include; ..\..\..\os\hal\platforms\STM32; ..\..\..\os\hal\platforms\STM32\DMAv1; ..\..\..\os\hal\platforms\STM32\GPIOv2; ..\..\..\os\hal\platforms\STM32\SPIv1; ..\..\..\os\hal\platforms\STM32\TIMv1; ..\..\..\os\hal\platforms\STM32\USARTv1; ..\..\..\os\hal\platforms\STM32F4xx; ..\..\..\os\various; ..\..\..\os\various\devices_lib\accel; ..\..\..\boards\ST_STM32F4_DISCOVERY; ..\..\..\test
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORTEX_USE_FPU=FALSE
  AARM.AUserIncludes: ..; ..\..\..\os\ports\IAR\ARMCMx\STM32F4xx; ..\..\..\boards\ST_STM32F4_DISCOVERY
  OBJCOPY.OOCOutputFile: ch.srec
  ILINK.IlinkOutputFile: ch.out
  ILINK.IlinkIcfFile: ch.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: CORTEX_USE_FPU=FALSE; NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: ch.hex
  group (top)
    ../: chconf.h halconf.h main.c mcuconf.h
  group board
    ../../../boards/ST_STM32F4_DISCOVERY/: board.c board.h
  group os/hal/include
    ../../../os/hal/include/: adc.h can.h ext.h gpt.h hal.h i2c.h icu.h mac.h mii.h mmc_spi.h pal.h pwm.h rtc.h sdc.h serial.h serial_usb.h spi.h uart.h usb.h usb_cdc.h
  group os/hal/src
    ../../../os/hal/src/: adc.c can.c ext.c gpt.c hal.c i2c.c icu.c mac.c mmc_spi.c pal.c pwm.c rtc.c sdc.c serial.c serial_usb.c spi.c uart.c usb.c
  group os/kernel/include
    ../../../os/kernel/include/: ch.h chcond.h chdebug.h chdynamic.h chevents.h chheap.h chinline.h chioch.h chlists.h chmboxes.h chmemcore.h chmempools.h chmsg.h chmtx.h chqueues.h chregistry.h chschd.h chsem.h chstreams.h chsys.h chthreads.h chvt.h
  group os/kernel/src
    ../../../os/kernel/src/: chcond.c chdebug.c chdynamic.c chevents.c chheap.c chlists.c chmboxes.c chmemcore.c chmempools.c chmsg.c chmtx.c chqueues.c chregistry.c chschd.c chsem.c chsys.c chthreads.c chvt.c
  group os/platform
    ../../../os/hal/platforms/STM32F4xx/: adc_lld.c adc_lld.h hal_lld.c hal_lld.h stm32_dma.c stm32_dma.h stm32_rcc.h stm32f4xx.h
    ../../../os/hal/platforms/STM32/GPIOv2/: pal_lld.c pal_lld.h
    ../../../os/hal/platforms/STM32/TIMv1/: pwm_lld.c pwm_lld.h
    ../../../os/hal/platforms/STM32/USARTv1/: serial_lld.c serial_lld.h
    ../../../os/hal/platforms/STM32/SPIv1/: spi_lld.c spi_lld.h
  group os/port
    ../../../os/ports/IAR/ARMCMx/: chcore.c chcore.h chcore_v7m.c chcore_v7m.h chcoreasm_v7m.s chtypes.h cstartup.s
    ../../../os/ports/common/ARMCMx/: nvic.c nvic.h
  group os/port/STM32F4xx
    ../../../os/ports/IAR/ARMCMx/STM32F4xx/: cmparams.h vectors.s
  group os/various
    ../../../os/various/: chprintf.c chprintf.h
  group os/various/devices_lib/accel
    ../../../os/various/devices_lib/accel/: lis302dl.c lis302dl.h
  group test
    ../../../test/: test.c test.h testbmk.c testbmk.h testdyn.c testdyn.h testevt.c testevt.h testheap.c testheap.h testmbox.c testmbox.h testmsg.c testmsg.h testmtx.c testmtx.h testpools.c testpools.h testqueues.c testqueues.h testsem.c testsem.h testthd.c testthd.h
